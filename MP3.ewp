# IAR project MP3.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2103 Philips LPC2103
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\Documents and Settings\Administrator\桌面\5.30am\5.30amMa\config\LPC2103_flash.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    source/: config.h Fat16.c Fat16.h LCD12864S_LPC2103.c sdcmd.c sdcmd.h sdconfig.h sdcrc.c sdcrc.h sddriver.c sddriver.h sdhal.c sdhal.h system.c system.h testmain.c vs1003_ssp.c vs1003_ssp.h
